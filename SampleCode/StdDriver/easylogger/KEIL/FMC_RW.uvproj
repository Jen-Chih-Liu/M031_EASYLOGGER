# Keil uVision project FMC_RW.uvproj, settings and files
target FMC_RW (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: fmc_rw
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\easyflash\inc;..\EasyLogger\inc;..\EasyLogger\plugins\flash
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c fmc.c clk.c
  group easyflash
    ../easyflash/src/: easyflash.c ef_env.c ef_iap.c ef_log.c ef_utils.c ef_env_legacy.c ef_env_legacy_wl.c
    ../easyflash/port/: ef_port.c
  group easylogger
    ../EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../EasyLogger/plugins/flash/: elog_flash.c elog_flash_port.c
    ../EasyLogger/port/: elog_port.c
